## tests/unit/snmp/testcase.yaml
```yaml
tests:
  unit.snmp:
    tags:
      - snmp
      - unit
    platform_allow:
      - native_sim
```
